PACKAGECONFIG[bfd] = ",NO_LIBBFD=1"
EXTRA_OEMAKE += "NO_LIBTRACEEVENT=1"
